## config/boards/shields/Knob/Kconfig.shield
```kconfig
config SHIELD_MEDIA_KNOB
    bool "Media Knob"
    depends on BOARD_NICE_NANO_V2
```
